# Keil uVision project dsps_device_ss.uvprojx, settings and files
target dsps_585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: dsps_device_585 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused.txt"
  c include: .\..\..\..\..\..\sdk6\sdk\platform\include;.\..\..\..\..\..\sdk6\sdk\app_modules\api;.\..\..\..\..\..\sdk6\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk6\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk6\sdk\app_modules\src\app_suotar;.\..\..\..\..\..\sdk6\sdk\app_modules\src\app_custs;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk6\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk6\sdk\ble_stack\hcih;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk6\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk6\sdk\ble_stack\ea\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\em\api;.\..\..\..\..\..\sdk6\sdk\common_project_files;.\..\..\..\..\..\sdk6\sdk\platform\arch;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk6\sdk\platform\arch\ll;.\..\..\..\..\..\sdk6\sdk\platform\arch\main;.\..\..\..\..\..\sdk6\sdk\platform\arch;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\sdk6\sdk\platform\driver\adc;.\..\..\..\..\..\sdk6\sdk\platform\driver\battery;.\..\..\..\..\..\sdk6\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk6\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk6\sdk\platform\driver\reg;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk6\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk6\sdk\platform\driver\systick;.\..\..\..\..\..\sdk6\sdk\platform\driver\trng;.\..\..\..\..\..\sdk6\sdk\platform\driver\uart;.\..\..\..\..\..\sdk6\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\sdk6\sdk\platform\driver\ble;.\..\..\..\..\..\sdk6\sdk\platform\driver\emi;.\..\..\..\..\..\sdk6\sdk\platform\driver\intc;.\..\..\..\..\..\sdk6\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\sdk6\sdk\platform\driver\dma;.\..\..\..\..\..\sdk6\sdk\platform\driver\pdm;.\..\src\config;.\..\src;..\..\..\..\..\sdk6\sdk\platform\system_library\include;..\src\custom_profile;.\..\..\..\..\..\sdk6\sdk\app_modules\api\app_proxr;.\..\..\..\..\..\sdk6\sdk\ble_stack\hci\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\hci\src;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom\custs\api;..\..\common\src\driver;..\..\common\src\profiles;..\..\common\src\;..\..\common\src\profiles\spss;..\..\..\..\..\sdk6\sdk\common_project_files;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler;.\..\..\..\..\..\sdk6\third_party\hash;.\..\..\..\..\..\sdk6\sdk\platform\utilities\otp_hdr;.\..\..\..\..\..\sdk6\sdk\platform\driver\i2c;..\..\common\src\configuration_storage;..\..\common\src\remote_configuration;..\..\common\src\user_services;..\..\sw_version;.\..\..\..\..\..\sdk6\third_party\crc32;..\..\..\..\..\sdk6\sdk\platform\include\CMSIS\5.6.0\Include;..\src\SPI_ADC;..\src\SS_InterfaceToBLE;..\..\..\..\..\sdk6\sdk\platform\driver\timer
  library: MicroLIB
  scatter file: ..\..\..\..\..\sdk6\sdk\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\sdk6\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=dsps_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../../../sdk6/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    ./../../../../../sdk6/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    ./../../../../../sdk6/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../../../sdk6/sdk/platform/core_modules/arch_console/: arch_console.c
    ./../../../../../sdk6/sdk/platform/core_modules/nvds/src/: nvds.c
    ./../../../../../sdk6/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c
    ../../../../../sdk6/sdk/platform/arch/main/: arch_rom.c
    ../../../../../sdk6/sdk/platform/system_library/output/Keil_5/: da14585_586.lib
    ../../../../../sdk6/third_party/hash/: hash.c
    ./../../../../../sdk6/sdk/platform/system_library/output/Keil_5/: da14531.lib
    ../../../../../sdk6/sdk/platform/utilities/otp_cs/: otp_cs.c
    ../../../../../sdk6/third_party/crc32/: crc32.c
  group sdk_driver
    ./../../../../../sdk6/sdk/platform/driver/syscntl/: syscntl.c
    ./../../../../../sdk6/sdk/platform/driver/gpio/: gpio.c
    ./../../../../../sdk6/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../../../../../sdk6/sdk/platform/driver/battery/: battery.c
    ./../../../../../sdk6/sdk/platform/driver/trng/: trng.c
    ./../../../../../sdk6/sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../../../../sdk6/sdk/platform/driver/spi/: spi_58x.c
    ./../../../../../sdk6/sdk/platform/driver/systick/: systick.c
    ./../../../../../sdk6/sdk/platform/driver/uart/: uart.c
    ../../../../../sdk6/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ../../../../../sdk6/sdk/platform/driver/dma/: dma.c
    ../../../../../sdk6/sdk/platform/driver/adc/: adc_58x.c adc_531.c
    ../../../../../sdk6/sdk/platform/driver/spi/: spi_531.c
    ../../../../../sdk6/sdk/platform/driver/timer/: timer2.c
  group sdk_ble
    ./../../../../../sdk6/sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    ./../../../../../sdk6/sdk/ble_stack/rwble/: rwble.c
    ./../../../../../sdk6/sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    ./../../../../../sdk6/sdk/ble_stack/host/att/attm/: attm_db_128.c
    ./../../../../../sdk6/sdk/ble_stack/profiles/custom/: custom_common.c
    ../../../../../sdk6/sdk/ble_stack/profiles/: prf.c
    ./../../../../../sdk6/sdk/ble_stack/profiles/: prf_utils.c
    ../../../../../sdk6/sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
    ../../../../../sdk6/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
  group sdk_app
    ./../../../../../sdk6/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../../../../../sdk6/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c
    ./../../../../../sdk6/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ./../../../../../sdk6/sdk/app_modules/src/app_entry/: app_entry_point.c
    ./../../../../../sdk6/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    ./../../../../../sdk6/sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    ../../../../../sdk6/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
  group sdk_driver_api
    ./../../../../../sdk6/sdk/platform/driver/adc/: adc.h
    ./../../../../../sdk6/sdk/platform/driver/battery/: battery.h
    ./../../../../../sdk6/sdk/platform/driver/gpio/: gpio.h
    ./../../../../../sdk6/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ./../../../../../sdk6/sdk/platform/driver/spi/: spi.h
    ./../../../../../sdk6/sdk/platform/driver/spi_flash/: spi_flash.h
    ./../../../../../sdk6/sdk/platform/driver/systick/: systick.h
    ./../../../../../sdk6/sdk/platform/driver/trng/: trng.h
    ./../../../../../sdk6/sdk/platform/driver/uart/: uart.h
    ./../../../../../sdk6/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    ./../../../../../sdk6/sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    ./../../../../../sdk6/sdk/platform/arch/main/: arch_wdg.h
    ./../../../../../sdk6/sdk/platform/arch/: arch_api.h
    ./../../../../../sdk6/sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_dsps_service
    ../../common/src/profiles/spss/: sps_server.c sps_server_task.c
    ../src/: user_sps_device_config.c user_spss.c user_spss_task.c
  group user_platform
    ./../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_sps_device_dma.c
    ../../common/src/: user_sps_utils.c user_sps_buffer_dma.c user_sps_schedule_dma.c
  group user_remote_config_service
    ../../common/src/remote_configuration/: remote_config.c remote_config_task.c
    ../../common/src/user_services/: user_remote_config.c user_remote_config_task.c
  group user_configuration_storage
    ../../common/src/configuration_storage/: user_config_storage.c
  group SS_InterfaceToBLE
    ../src/SS_InterfaceToBLE/: SS_InterfaceToBLE.c SS_InterfaceToBLE.h
  group SPI_ADC
    ../src/SPI_ADC/: SPI_ADC.c SPI_ADC.h
target dsps_531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: dsps_device_531 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: .\..\..\..\..\..\sdk6\sdk\platform\include;.\..\..\..\..\..\sdk6\sdk\app_modules\api;.\..\..\..\..\..\sdk6\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk6\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk6\sdk\app_modules\src\app_suotar;.\..\..\..\..\..\sdk6\sdk\app_modules\src\app_custs;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk6\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk6\sdk\ble_stack\hcih;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk6\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk6\sdk\ble_stack\ea\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\em\api;.\..\..\..\..\..\sdk6\sdk\common_project_files;.\..\..\..\..\..\sdk6\sdk\platform\arch;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk6\sdk\platform\arch\ll;.\..\..\..\..\..\sdk6\sdk\platform\arch\main;.\..\..\..\..\..\sdk6\sdk\platform\arch;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\sdk6\sdk\platform\driver\adc;.\..\..\..\..\..\sdk6\sdk\platform\driver\battery;.\..\..\..\..\..\sdk6\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk6\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk6\sdk\platform\driver\reg;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk6\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk6\sdk\platform\driver\systick;.\..\..\..\..\..\sdk6\sdk\platform\driver\trng;.\..\..\..\..\..\sdk6\sdk\platform\driver\uart;.\..\..\..\..\..\sdk6\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\sdk6\sdk\platform\driver\ble;.\..\..\..\..\..\sdk6\sdk\platform\driver\emi;.\..\..\..\..\..\sdk6\sdk\platform\driver\intc;.\..\..\..\..\..\sdk6\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\sdk6\sdk\platform\driver\dma;.\..\..\..\..\..\sdk6\sdk\platform\driver\pdm;.\..\src\config;.\..\src;..\..\..\..\..\sdk6\sdk\platform\system_library\include;..\src\custom_profile;.\..\..\..\..\..\sdk6\sdk\app_modules\api\app_proxr;.\..\..\..\..\..\sdk6\sdk\ble_stack\hci\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\hci\src;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom\custs\api;..\..\common\src\driver;..\..\common\src\profiles;..\..\common\src\;..\..\common\src\profiles\spss;..\..\..\..\..\sdk6\sdk\common_project_files;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler;.\..\..\..\..\..\sdk6\sdk\platform\arch\ll;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot;.\..\..\..\..\..\sdk6\third_party\hash;.\..\..\..\..\..\sdk6\third_party\irng;.\..\..\..\..\..\sdk6\sdk\platform\utilities\otp_cs;.\..\..\..\..\..\sdk6\sdk\platform\utilities\otp_hdr;.\..\..\..\..\..\sdk6\sdk\platform\driver\i2c;..\..\common\src\configuration_storage;..\..\common\src\remote_configuration;..\..\common\src\user_services;..\..\sw_version;.\..\..\..\..\..\sdk6\third_party\crc32;..\..\..\..\..\sdk6\sdk\platform\include\CMSIS\5.6.0\Include;..\src\SS_InterfaceToBLE;..\src\SPI_ADC;..\..\..\..\..\sdk6\sdk\platform\driver\timer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\sdk6\sdk\common_project_files\scatterfiles\DA14531_all_ram_ret.sct
  link misc: --feedback=".\unused_531.txt" .\..\..\..\..\..\projects\target_apps\dsps\common\misc\da14531_symbols.txt  --symdefs dsps_531_symdef.txt  --any_placement=best_fit --datacompressor off
target SoundSensor_Fix (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: SS_Fix +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__ __SoundSensor__  __SSFix__
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: as above
