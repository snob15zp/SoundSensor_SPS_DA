# Keil uVision project secondary_bootloader.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: secondary_bootloader_585 +hex
  AfterMake: fromelf --bincombined --output=".\bin\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __NON_BLE_EXAMPLE__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --feedback=".\unused_585.txt"
  c include: .\includes;..\..\sdk6\sdk\platform\include;..\..\sdk6\sdk\platform\driver\spi;..\..\sdk6\sdk\platform\driver\i2c_eeprom;..\..\sdk6\sdk\platform\driver\i2c;..\..\sdk6\sdk\platform\driver\spi_flash;..\..\sdk6\sdk\platform\driver\gpio;..\..\sdk6\sdk\platform\driver\dma;..\..\sdk6\sdk\platform\arch;..\..\sdk6\sdk\platform\arch\compiler;..\..\sdk6\sdk\platform\arch\ll;..\..\sdk6\sdk\platform\driver\reg;..\..\sdk6\sdk\platform\driver\syscntl;..\..\sdk6\sdk\platform\driver\uart;..\..\sdk6\sdk\platform\driver\timer;..\..\sdk6\sdk\platform\core_modules\crypto;..\..\sdk6\sdk\platform\driver\systick;..\..\sdk6\sdk\platform\driver\hw_otpc;..\..\sdk6\sdk\platform\arch\main;..\..\sdk6\sdk\platform\core_modules\nvds\api;..\..\sdk6\sdk\platform\utilities\otp_hdr;..\..\sdk6\sdk\platform\include\CMSIS\5.6.0\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\bootloader_585.sct
  link misc: --feedback=".\unused_585.txt"
  group boot
    ../../sdk6/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    ../../sdk6/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    ../../sdk6/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group src
    ./src/: bootloader.c main.c uart_booter.c decrypt.c user_periph_setup.c
    ../../sdk6/sdk/platform/driver/spi_flash/: spi_flash.c
    ../../sdk6/sdk/platform/driver/gpio/: gpio.c
    ../../sdk6/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../sdk6/third_party/crc32/: crc32.c
    ../../sdk6/sdk/platform/core_modules/crypto/: sw_aes.c
    ../../sdk6/sdk/platform/driver/dma/: dma.c
    ../../sdk6/sdk/platform/driver/spi/: spi_58x.c spi_531.c
    ../../sdk6/sdk/platform/driver/i2c/: i2c.c
    ../../sdk6/sdk/platform/driver/uart/: uart.c
    ../../sdk6/sdk/platform/driver/systick/: systick.c
    ../../sdk6/sdk/platform/driver/syscntl/: syscntl.c
    ../../sdk6/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ../../sdk6/sdk/platform/driver/adc/: adc_531.c
    ../../sdk6/sdk/platform/utilities/otp_cs/: otp_cs.c
    ../../sdk6/sdk/platform/arch/main/: arch_system.c
  group includes
    ./includes/: user_periph_setup.h uart_booter.h bootloader.h os_int.h os_port.h da1458x_config_basic.h
    ../../sdk6/sdk/platform/include/: datasheet.h
    ../../sdk6/sdk/platform/driver/spi/: spi.h
    ../../sdk6/sdk/platform/driver/spi_flash/: spi_flash.h
    ../../sdk6/sdk/platform/driver/gpio/: gpio.h
    ../../sdk6/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ../../sdk6/sdk/platform/core_modules/crypto/: sw_aes.h
    ../../sdk6/sdk/platform/driver/uart/: uart.h
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: secondary_bootloader_531 +hex
  AfterMake: fromelf --bincombined --output=".\bin\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DA14531__  __NON_BLE_EXAMPLE__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --feedback=".\unused_531.txt"
  c include: .\includes;..\..\sdk6\sdk\platform\include;..\..\sdk6\sdk\platform\driver\spi;..\..\sdk6\sdk\platform\driver\i2c_eeprom;..\..\sdk6\sdk\platform\driver\i2c;..\..\sdk6\sdk\platform\driver\spi_flash;..\..\sdk6\sdk\platform\driver\gpio;..\..\sdk6\sdk\platform\driver\dma;..\..\sdk6\sdk\platform\arch;..\..\sdk6\sdk\platform\arch\compiler;..\..\sdk6\sdk\platform\arch\ll;..\..\sdk6\sdk\platform\driver\reg;..\..\sdk6\sdk\platform\driver\syscntl;..\..\sdk6\sdk\platform\driver\uart;..\..\sdk6\sdk\platform\driver\timer;..\..\sdk6\sdk\platform\core_modules\crypto;..\..\sdk6\sdk\platform\driver\systick;..\..\sdk6\sdk\platform\driver\hw_otpc;..\..\sdk6\sdk\platform\utilities\otp_cs;..\..\sdk6\sdk\platform\driver\adc;..\..\sdk6\sdk\platform\core_modules\rf\api;..\..\sdk6\sdk\platform\arch\main;..\..\sdk6\sdk\platform\core_modules\nvds\api;..\..\sdk6\sdk\platform\utilities\otp_hdr;..\..\sdk6\sdk\platform\arch\main;..\..\sdk6\sdk\platform\include\CMSIS\5.6.0\Include
  asm include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\bootloader_531.sct
  link misc: --feedback=".\unused_531.txt"
