# Keil uVision project systick_a.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: systick_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __NON_BLE_EXAMPLE__
  c misc: --thumb -c --feedback=".\unused_585.txt"
  c include: .\..\..\..\..\..\sdk6\sdk\app_modules\api;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk6\sdk\ble_stack\ea\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\em\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\hci\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\hci\src;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anc\ancc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp\anpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp\anps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\basc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs\bcsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs\bcss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp\blpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp\blps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms\bmsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms\bmss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp\cppc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp\cpps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp\cscpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp\cscps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts\ctsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts\ctss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\disc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find\findl\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find\findt\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\gatt\gatt_client\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp\glpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp\glps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogpbh\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogpd\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogprh\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp\hrpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp\hrps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp\htpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp\htpt\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan\lanc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan\lans\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp\paspc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp\pasps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxm\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp\rscpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp\rscps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp\scppc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp\scpps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip\tipc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip\tips\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds\udsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds\udss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss\wssc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss\wsss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk6\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk6\sdk\common_project_files;.\..\..\..\..\..\sdk6\sdk\platform\arch;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot\ARM;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot\GCC;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler\ARM;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler\GCC;.\..\..\..\..\..\sdk6\sdk\platform\arch\ll;.\..\..\..\..\..\sdk6\sdk\platform\arch\main;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk6\sdk\platform\driver\adc;.\..\..\..\..\..\sdk6\sdk\platform\driver\battery;.\..\..\..\..\..\sdk6\sdk\platform\driver\ble;.\..\..\..\..\..\sdk6\sdk\platform\driver\dma;.\..\..\..\..\..\sdk6\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk6\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\sdk6\sdk\platform\driver\i2c;.\..\..\..\..\..\sdk6\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk6\sdk\platform\driver\pdm;.\..\..\..\..\..\sdk6\sdk\platform\driver\reg;.\..\..\..\..\..\sdk6\sdk\platform\driver\rtc;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi_hci;.\..\..\..\..\..\sdk6\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk6\sdk\platform\driver\systick;.\..\..\..\..\..\sdk6\sdk\platform\driver\timer;.\..\..\..\..\..\sdk6\sdk\platform\driver\trng;.\..\..\..\..\..\sdk6\sdk\platform\driver\uart;.\..\..\..\..\..\sdk6\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\sdk6\sdk\platform\include;.\..\..\..\..\..\sdk6\sdk\platform\system_library\include;.\..\..\..\..\..\third_party\hash;.\..\..\..\..\..\third_party\rand;.\..\include;.\..\..\shared\api;..\..\..\..\..\sdk6\sdk\platform\utilities\otp_hdr;..\..\..\..\..\sdk6\sdk\platform\include\CMSIS\5.6.0\Include
  library: MicroLIB
  scatter file: ..\..\shared\peripheral_examples.sct
  link misc: --feedback=".\unused_585.txt"
  group sdk_boot
    ../../../../../sdk6/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    ../../../../../sdk6/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    ../../shared/source/: exceptions.c
  group sdk_driver
    ../../../../../sdk6/sdk/platform/driver/syscntl/: syscntl.c
    ../../../../../sdk6/sdk/platform/driver/gpio/: gpio.c
    ../../../../../sdk6/sdk/platform/driver/uart/: uart.c uart_utils.c
    ../../../../../sdk6/sdk/platform/driver/systick/: systick.c
    ../../../../../sdk6/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ../../../../../sdk6/sdk/platform/utilities/otp_cs/: otp_cs.c
    ../../../../../sdk6/sdk/platform/driver/spi_flash/: spi_flash.c
    ../../../../../sdk6/sdk/platform/driver/spi/: spi_58x.c
  group user_app
    ../src/: main.c
    ../../../../../sdk6/sdk/platform/arch/main/: arch_system.c
  group SPI_ADC
    ../../dsps_device/src/SPI_ADC/: SPI_ADC.c SPI_ADC.h
  group user_platform
    ../src/: user_periph_setup.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: systick_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__ __NON_BLE_EXAMPLE__
  c misc: --thumb -c --feedback=".\unused_586.txt"
  c include: .\..\..\..\..\..\sdk6\sdk\app_modules\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk6\sdk\ble_stack\ea\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\em\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\hci\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\hci\src;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anc\ancc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp\anpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp\anps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\basc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs\bcsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs\bcss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp\blpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp\blps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms\bmsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms\bmss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp\cppc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp\cpps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp\cscpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp\cscps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts\ctsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts\ctss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\disc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find\findl\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find\findt\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\gatt\gatt_client\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp\glpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp\glps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogpbh\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogpd\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogprh\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp\hrpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp\hrps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp\htpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp\htpt\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan\lanc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan\lans\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp\paspc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp\pasps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxm\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp\rscpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp\rscps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp\scppc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp\scpps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip\tipc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip\tips\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds\udsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds\udss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss\wssc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss\wsss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk6\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk6\sdk\common_project_files;.\..\..\..\..\..\sdk6\sdk\platform\arch;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot\ARM;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot\GCC;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler\ARM;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler\GCC;.\..\..\..\..\..\sdk6\sdk\platform\arch\ll;.\..\..\..\..\..\sdk6\sdk\platform\arch\main;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk6\sdk\platform\driver\adc;.\..\..\..\..\..\sdk6\sdk\platform\driver\battery;.\..\..\..\..\..\sdk6\sdk\platform\driver\ble;.\..\..\..\..\..\sdk6\sdk\platform\driver\dma;.\..\..\..\..\..\sdk6\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk6\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\sdk6\sdk\platform\driver\i2c;.\..\..\..\..\..\sdk6\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk6\sdk\platform\driver\pdm;.\..\..\..\..\..\sdk6\sdk\platform\driver\reg;.\..\..\..\..\..\sdk6\sdk\platform\driver\rtc;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi_hci;.\..\..\..\..\..\sdk6\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk6\sdk\platform\driver\systick;.\..\..\..\..\..\sdk6\sdk\platform\driver\timer;.\..\..\..\..\..\sdk6\sdk\platform\driver\trng;.\..\..\..\..\..\sdk6\sdk\platform\driver\uart;.\..\..\..\..\..\sdk6\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\sdk6\sdk\platform\include;.\..\..\..\..\..\sdk6\sdk\platform\system_library\include;.\..\..\..\..\..\third_party\hash;.\..\..\..\..\..\third_party\rand;.\..\include;.\..\..\shared\api;..\..\..\..\..\sdk6\sdk\platform\utilities\otp_hdr;..\..\..\..\..\sdk6\sdk\platform\include\CMSIS\5.6.0\Include
  library: MicroLIB
  scatter file: ..\..\shared\peripheral_examples.sct
  link misc: --feedback=".\unused_586.txt"
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: systick_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: __DA14531__ __NON_BLE_EXAMPLE__
  c misc: --thumb -c --feedback=".\unused_531.txt"
  c include: .\..\..\..\..\..\sdk6\sdk\app_modules\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk6\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk6\sdk\ble_stack\ea\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\em\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\hci\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\hci\src;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anc\ancc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp\anpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp\anps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\basc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs\bcsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs\bcss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp\blpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp\blps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms\bmsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms\bmss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp\cppc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp\cpps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp\cscpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp\cscps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts\ctsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts\ctss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\disc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find\findl\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find\findt\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\gatt\gatt_client\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp\glpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp\glps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogpbh\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogpd\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogprh\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp\hrpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp\hrps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp\htpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp\htpt\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan\lanc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan\lans\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp\paspc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp\pasps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxm\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp\rscpc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp\rscps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp\scppc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp\scpps\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip\tipc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip\tips\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds\udsc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds\udss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss\wssc\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss\wsss\api;.\..\..\..\..\..\sdk6\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk6\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk6\sdk\common_project_files;.\..\..\..\..\..\sdk6\sdk\platform\arch;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot\ARM;.\..\..\..\..\..\sdk6\sdk\platform\arch\boot\GCC;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler\ARM;.\..\..\..\..\..\sdk6\sdk\platform\arch\compiler\GCC;.\..\..\..\..\..\sdk6\sdk\platform\arch\ll;.\..\..\..\..\..\sdk6\sdk\platform\arch\main;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk6\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk6\sdk\platform\driver\adc;.\..\..\..\..\..\sdk6\sdk\platform\driver\battery;.\..\..\..\..\..\sdk6\sdk\platform\driver\ble;.\..\..\..\..\..\sdk6\sdk\platform\driver\dma;.\..\..\..\..\..\sdk6\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk6\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\sdk6\sdk\platform\driver\i2c;.\..\..\..\..\..\sdk6\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk6\sdk\platform\driver\pdm;.\..\..\..\..\..\sdk6\sdk\platform\driver\reg;.\..\..\..\..\..\sdk6\sdk\platform\driver\rtc;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk6\sdk\platform\driver\spi_hci;.\..\..\..\..\..\sdk6\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk6\sdk\platform\driver\systick;.\..\..\..\..\..\sdk6\sdk\platform\driver\timer;.\..\..\..\..\..\sdk6\sdk\platform\driver\trng;.\..\..\..\..\..\sdk6\sdk\platform\driver\uart;.\..\..\..\..\..\sdk6\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\sdk6\sdk\platform\include;.\..\..\..\..\..\sdk6\sdk\platform\system_library\include;.\..\..\..\..\..\third_party\hash;.\..\..\..\..\..\third_party\rand;.\..\include;.\..\..\shared\api;..\..\..\..\..\sdk6\sdk\platform\utilities\otp_hdr;..\..\..\..\..\sdk6\sdk\platform\utilities\otp_cs;..\..\..\..\..\sdk6\sdk\platform\include\CMSIS\5.6.0\Include;..\..\..\..\..\IRR_2_FP_keil\IIR_2_ML;..\..\..\..\..\IRR_2p2_FP32s_keil\IIR_2p3_ML
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\shared\peripheral_examples.sct
  link misc: --feedback=".\unused_531.txt"
target SoundSensor_Fix (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: systick_531 +hex
  AfterMake: as above
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: __DA14531__ __NON_BLE_EXAMPLE__ __SoundSensor__  __SSFix__ __EXCLUDE_GPIO0_HANDLER__
  c misc: --thumb -c --feedback=".\unused_531.txt"
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\shared\peripheral_examples.sct
  link misc: --feedback=".\unused_531.txt"
